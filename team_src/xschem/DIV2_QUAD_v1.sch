v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {symbols/nfet_03v3.sym} 0 0 0 0 {name=MA1 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} -20 0 0 0 {name=lp1 lab=OQ}
C {lab_pin.sym} 20 -30 0 0 {name=lp2 lab=OIB}
C {lab_pin.sym} 20 30 0 0 {name=lp3 lab=nTA}
C {lab_pin.sym} 20 0 0 0 {name=lp4 lab=VSS}
C {symbols/nfet_03v3.sym} 260 0 0 0 {name=MA2 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 240 0 0 0 {name=lp5 lab=OQB}
C {lab_pin.sym} 280 -30 0 0 {name=lp6 lab=OI}
C {lab_pin.sym} 280 30 0 0 {name=lp7 lab=nTA}
C {lab_pin.sym} 280 0 0 0 {name=lp8 lab=VSS}
C {symbols/nfet_03v3.sym} 520 0 0 0 {name=MA3 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 500 0 0 0 {name=lp9 lab=OI}
C {lab_pin.sym} 540 -30 0 0 {name=lp10 lab=OIB}
C {lab_pin.sym} 540 30 0 0 {name=lp11 lab=nLA}
C {lab_pin.sym} 540 0 0 0 {name=lp12 lab=VSS}
C {symbols/nfet_03v3.sym} 780 0 0 0 {name=MA4 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 760 0 0 0 {name=lp13 lab=OIB}
C {lab_pin.sym} 800 -30 0 0 {name=lp14 lab=OI}
C {lab_pin.sym} 800 30 0 0 {name=lp15 lab=nLA}
C {lab_pin.sym} 800 0 0 0 {name=lp16 lab=VSS}
C {symbols/nfet_03v3.sym} 1040 0 0 0 {name=MA5 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 1020 0 0 0 {name=lp17 lab=CK}
C {lab_pin.sym} 1060 -30 0 0 {name=lp18 lab=nTA}
C {lab_pin.sym} 1060 30 0 0 {name=lp19 lab=TAILA}
C {lab_pin.sym} 1060 0 0 0 {name=lp20 lab=VSS}
C {symbols/nfet_03v3.sym} 1300 0 0 0 {name=MA6 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 1280 0 0 0 {name=lp21 lab=CKB}
C {lab_pin.sym} 1320 -30 0 0 {name=lp22 lab=nLA}
C {lab_pin.sym} 1320 30 0 0 {name=lp23 lab=TAILA}
C {lab_pin.sym} 1320 0 0 0 {name=lp24 lab=VSS}
C {symbols/nfet_03v3.sym} 0 500 0 0 {name=MB1 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} -20 500 0 0 {name=lp25 lab=OIB}
C {lab_pin.sym} 20 470 0 0 {name=lp26 lab=OQB}
C {lab_pin.sym} 20 530 0 0 {name=lp27 lab=nTB}
C {lab_pin.sym} 20 500 0 0 {name=lp28 lab=VSS}
C {symbols/nfet_03v3.sym} 260 500 0 0 {name=MB2 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 240 500 0 0 {name=lp29 lab=OI}
C {lab_pin.sym} 280 470 0 0 {name=lp30 lab=OQ}
C {lab_pin.sym} 280 530 0 0 {name=lp31 lab=nTB}
C {lab_pin.sym} 280 500 0 0 {name=lp32 lab=VSS}
C {symbols/nfet_03v3.sym} 520 500 0 0 {name=MB3 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 500 500 0 0 {name=lp33 lab=OQ}
C {lab_pin.sym} 540 470 0 0 {name=lp34 lab=OQB}
C {lab_pin.sym} 540 530 0 0 {name=lp35 lab=nLB}
C {lab_pin.sym} 540 500 0 0 {name=lp36 lab=VSS}
C {symbols/nfet_03v3.sym} 780 500 0 0 {name=MB4 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 760 500 0 0 {name=lp37 lab=OQB}
C {lab_pin.sym} 800 470 0 0 {name=lp38 lab=OQ}
C {lab_pin.sym} 800 530 0 0 {name=lp39 lab=nLB}
C {lab_pin.sym} 800 500 0 0 {name=lp40 lab=VSS}
C {symbols/nfet_03v3.sym} 1040 500 0 0 {name=MB5 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 1020 500 0 0 {name=lp41 lab=CKB}
C {lab_pin.sym} 1060 470 0 0 {name=lp42 lab=nTB}
C {lab_pin.sym} 1060 530 0 0 {name=lp43 lab=TAILB}
C {lab_pin.sym} 1060 500 0 0 {name=lp44 lab=VSS}
C {symbols/nfet_03v3.sym} 1300 500 0 0 {name=MB6 L=0.3u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 1280 500 0 0 {name=lp45 lab=CK}
C {lab_pin.sym} 1320 470 0 0 {name=lp46 lab=nLB}
C {lab_pin.sym} 1320 530 0 0 {name=lp47 lab=TAILB}
C {lab_pin.sym} 1320 500 0 0 {name=lp48 lab=VSS}
C {res.sym} 0 -400 0 0 {name=RA1 value=300 footprint=1206 device=resistor m=1}
C {lab_pin.sym} 0 -430 0 0 {name=lp49 lab=VDD}
C {lab_pin.sym} 0 -370 0 0 {name=lp50 lab=OIB}
C {res.sym} 260 -400 0 0 {name=RA2 value=300 footprint=1206 device=resistor m=1}
C {lab_pin.sym} 260 -430 0 0 {name=lp51 lab=VDD}
C {lab_pin.sym} 260 -370 0 0 {name=lp52 lab=OI}
C {res.sym} 520 -400 0 0 {name=RB1 value=300 footprint=1206 device=resistor m=1}
C {lab_pin.sym} 520 -430 0 0 {name=lp53 lab=VDD}
C {lab_pin.sym} 520 -370 0 0 {name=lp54 lab=OQB}
C {res.sym} 780 -400 0 0 {name=RB2 value=300 footprint=1206 device=resistor m=1}
C {lab_pin.sym} 780 -430 0 0 {name=lp55 lab=VDD}
C {lab_pin.sym} 780 -370 0 0 {name=lp56 lab=OQ}
C {symbols/nfet_03v3.sym} 0 1100 0 0 {name=M_BREF L=1u W=4u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} -20 1100 0 0 {name=lp57 lab=IBIAS}
C {lab_pin.sym} 20 1070 0 0 {name=lp58 lab=IBIAS}
C {lab_pin.sym} 20 1130 0 0 {name=lp59 lab=VSS}
C {lab_pin.sym} 20 1100 0 0 {name=lp60 lab=VSS}
C {symbols/nfet_03v3.sym} 260 1100 0 0 {name=M_TAILA L=1u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 240 1100 0 0 {name=lp61 lab=IBIAS}
C {lab_pin.sym} 280 1070 0 0 {name=lp62 lab=TAILA}
C {lab_pin.sym} 280 1130 0 0 {name=lp63 lab=VSS}
C {lab_pin.sym} 280 1100 0 0 {name=lp64 lab=VSS}
C {symbols/nfet_03v3.sym} 520 1100 0 0 {name=M_TAILB L=1u W=40u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 500 1100 0 0 {name=lp65 lab=IBIAS}
C {lab_pin.sym} 540 1070 0 0 {name=lp66 lab=TAILB}
C {lab_pin.sym} 540 1130 0 0 {name=lp67 lab=VSS}
C {lab_pin.sym} 540 1100 0 0 {name=lp68 lab=VSS}
C {symbols/nfet_03v3.sym} 780 1100 0 0 {name=M_PBN L=1u W=4u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 760 1100 0 0 {name=lp69 lab=IBIAS}
C {lab_pin.sym} 800 1070 0 0 {name=lp70 lab=nPB}
C {lab_pin.sym} 800 1130 0 0 {name=lp71 lab=VSS}
C {lab_pin.sym} 800 1100 0 0 {name=lp72 lab=VSS}
C {symbols/pfet_03v3.sym} 1040 1100 0 0 {name=M_PBP L=1u W=8u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 1020 1100 0 0 {name=lp73 lab=nPB}
C {lab_pin.sym} 1060 1130 0 0 {name=lp74 lab=nPB}
C {lab_pin.sym} 1060 1070 0 0 {name=lp75 lab=VDD}
C {lab_pin.sym} 1060 1100 0 0 {name=lp76 lab=VDD}
C {symbols/pfet_03v3.sym} -100 1600 0 0 {name=M_BT_IP L=0.5u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} -120 1600 0 0 {name=lp77 lab=nPB}
C {lab_pin.sym} -80 1630 0 0 {name=lp78 lab=BS_IP}
C {lab_pin.sym} -80 1570 0 0 {name=lp79 lab=VDD}
C {lab_pin.sym} -80 1600 0 0 {name=lp80 lab=VDD}
C {symbols/pfet_03v3.sym} 160 1600 0 0 {name=M_BP1_IP L=0.3u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 140 1600 0 0 {name=lp81 lab=OIB}
C {lab_pin.sym} 180 1630 0 0 {name=lp82 lab=DN1_IP}
C {lab_pin.sym} 180 1570 0 0 {name=lp83 lab=BS_IP}
C {lab_pin.sym} 180 1600 0 0 {name=lp84 lab=VDD}
C {symbols/pfet_03v3.sym} 420 1600 0 0 {name=M_BP2_IP L=0.3u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 400 1600 0 0 {name=lp85 lab=OI}
C {lab_pin.sym} 440 1630 0 0 {name=lp86 lab=OC_IP}
C {lab_pin.sym} 440 1570 0 0 {name=lp87 lab=BS_IP}
C {lab_pin.sym} 440 1600 0 0 {name=lp88 lab=VDD}
C {symbols/nfet_03v3.sym} -100 2000 0 0 {name=M_BN1_IP L=0.3u W=8u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} -120 2000 0 0 {name=lp89 lab=DN1_IP}
C {lab_pin.sym} -80 1970 0 0 {name=lp90 lab=DN1_IP}
C {lab_pin.sym} -80 2030 0 0 {name=lp91 lab=VSS}
C {lab_pin.sym} -80 2000 0 0 {name=lp92 lab=VSS}
C {symbols/nfet_03v3.sym} 160 2000 0 0 {name=M_BN2_IP L=0.3u W=8u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 140 2000 0 0 {name=lp93 lab=DN1_IP}
C {lab_pin.sym} 180 1970 0 0 {name=lp94 lab=OC_IP}
C {lab_pin.sym} 180 2030 0 0 {name=lp95 lab=VSS}
C {lab_pin.sym} 180 2000 0 0 {name=lp96 lab=VSS}
C {symbols/pfet_03v3.sym} 680 1600 0 0 {name=M_IP_IP L=0.3u W=8u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 660 1600 0 0 {name=lp97 lab=OC_IP}
C {lab_pin.sym} 700 1630 0 0 {name=lp98 lab=INVO_IP}
C {lab_pin.sym} 700 1570 0 0 {name=lp99 lab=VDD}
C {lab_pin.sym} 700 1600 0 0 {name=lp100 lab=VDD}
C {symbols/nfet_03v3.sym} 680 2000 0 0 {name=M_IN_IP L=0.3u W=4u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 660 2000 0 0 {name=lp101 lab=OC_IP}
C {lab_pin.sym} 700 1970 0 0 {name=lp102 lab=INVO_IP}
C {lab_pin.sym} 700 2030 0 0 {name=lp103 lab=VSS}
C {lab_pin.sym} 700 2000 0 0 {name=lp104 lab=VSS}
C {res.sym} 940 1800 0 0 {name=R_SER_IP value=450 footprint=1206 device=resistor m=1}
C {lab_pin.sym} 940 1770 0 0 {name=lp105 lab=INVO_IP}
C {lab_pin.sym} 940 1830 0 0 {name=lp106 lab=I_P}
C {symbols/pfet_03v3.sym} 1400 1600 0 0 {name=M_BT_IN L=0.5u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 1380 1600 0 0 {name=lp107 lab=nPB}
C {lab_pin.sym} 1420 1630 0 0 {name=lp108 lab=BS_IN}
C {lab_pin.sym} 1420 1570 0 0 {name=lp109 lab=VDD}
C {lab_pin.sym} 1420 1600 0 0 {name=lp110 lab=VDD}
C {symbols/pfet_03v3.sym} 1660 1600 0 0 {name=M_BP1_IN L=0.3u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 1640 1600 0 0 {name=lp111 lab=OI}
C {lab_pin.sym} 1680 1630 0 0 {name=lp112 lab=DN1_IN}
C {lab_pin.sym} 1680 1570 0 0 {name=lp113 lab=BS_IN}
C {lab_pin.sym} 1680 1600 0 0 {name=lp114 lab=VDD}
C {symbols/pfet_03v3.sym} 1920 1600 0 0 {name=M_BP2_IN L=0.3u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 1900 1600 0 0 {name=lp115 lab=OIB}
C {lab_pin.sym} 1940 1630 0 0 {name=lp116 lab=OC_IN}
C {lab_pin.sym} 1940 1570 0 0 {name=lp117 lab=BS_IN}
C {lab_pin.sym} 1940 1600 0 0 {name=lp118 lab=VDD}
C {symbols/nfet_03v3.sym} 1400 2000 0 0 {name=M_BN1_IN L=0.3u W=8u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 1380 2000 0 0 {name=lp119 lab=DN1_IN}
C {lab_pin.sym} 1420 1970 0 0 {name=lp120 lab=DN1_IN}
C {lab_pin.sym} 1420 2030 0 0 {name=lp121 lab=VSS}
C {lab_pin.sym} 1420 2000 0 0 {name=lp122 lab=VSS}
C {symbols/nfet_03v3.sym} 1660 2000 0 0 {name=M_BN2_IN L=0.3u W=8u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 1640 2000 0 0 {name=lp123 lab=DN1_IN}
C {lab_pin.sym} 1680 1970 0 0 {name=lp124 lab=OC_IN}
C {lab_pin.sym} 1680 2030 0 0 {name=lp125 lab=VSS}
C {lab_pin.sym} 1680 2000 0 0 {name=lp126 lab=VSS}
C {symbols/pfet_03v3.sym} 2180 1600 0 0 {name=M_IP_IN L=0.3u W=8u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 2160 1600 0 0 {name=lp127 lab=OC_IN}
C {lab_pin.sym} 2200 1630 0 0 {name=lp128 lab=INVO_IN}
C {lab_pin.sym} 2200 1570 0 0 {name=lp129 lab=VDD}
C {lab_pin.sym} 2200 1600 0 0 {name=lp130 lab=VDD}
C {symbols/nfet_03v3.sym} 2180 2000 0 0 {name=M_IN_IN L=0.3u W=4u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 2160 2000 0 0 {name=lp131 lab=OC_IN}
C {lab_pin.sym} 2200 1970 0 0 {name=lp132 lab=INVO_IN}
C {lab_pin.sym} 2200 2030 0 0 {name=lp133 lab=VSS}
C {lab_pin.sym} 2200 2000 0 0 {name=lp134 lab=VSS}
C {res.sym} 2440 1800 0 0 {name=R_SER_IN value=450 footprint=1206 device=resistor m=1}
C {lab_pin.sym} 2440 1770 0 0 {name=lp135 lab=INVO_IN}
C {lab_pin.sym} 2440 1830 0 0 {name=lp136 lab=I_N}
C {symbols/pfet_03v3.sym} 2900 1600 0 0 {name=M_BT_QP L=0.5u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 2880 1600 0 0 {name=lp137 lab=nPB}
C {lab_pin.sym} 2920 1630 0 0 {name=lp138 lab=BS_QP}
C {lab_pin.sym} 2920 1570 0 0 {name=lp139 lab=VDD}
C {lab_pin.sym} 2920 1600 0 0 {name=lp140 lab=VDD}
C {symbols/pfet_03v3.sym} 3160 1600 0 0 {name=M_BP1_QP L=0.3u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 3140 1600 0 0 {name=lp141 lab=OQB}
C {lab_pin.sym} 3180 1630 0 0 {name=lp142 lab=DN1_QP}
C {lab_pin.sym} 3180 1570 0 0 {name=lp143 lab=BS_QP}
C {lab_pin.sym} 3180 1600 0 0 {name=lp144 lab=VDD}
C {symbols/pfet_03v3.sym} 3420 1600 0 0 {name=M_BP2_QP L=0.3u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 3400 1600 0 0 {name=lp145 lab=OQ}
C {lab_pin.sym} 3440 1630 0 0 {name=lp146 lab=OC_QP}
C {lab_pin.sym} 3440 1570 0 0 {name=lp147 lab=BS_QP}
C {lab_pin.sym} 3440 1600 0 0 {name=lp148 lab=VDD}
C {symbols/nfet_03v3.sym} 2900 2000 0 0 {name=M_BN1_QP L=0.3u W=8u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 2880 2000 0 0 {name=lp149 lab=DN1_QP}
C {lab_pin.sym} 2920 1970 0 0 {name=lp150 lab=DN1_QP}
C {lab_pin.sym} 2920 2030 0 0 {name=lp151 lab=VSS}
C {lab_pin.sym} 2920 2000 0 0 {name=lp152 lab=VSS}
C {symbols/nfet_03v3.sym} 3160 2000 0 0 {name=M_BN2_QP L=0.3u W=8u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 3140 2000 0 0 {name=lp153 lab=DN1_QP}
C {lab_pin.sym} 3180 1970 0 0 {name=lp154 lab=OC_QP}
C {lab_pin.sym} 3180 2030 0 0 {name=lp155 lab=VSS}
C {lab_pin.sym} 3180 2000 0 0 {name=lp156 lab=VSS}
C {symbols/pfet_03v3.sym} 3680 1600 0 0 {name=M_IP_QP L=0.3u W=8u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 3660 1600 0 0 {name=lp157 lab=OC_QP}
C {lab_pin.sym} 3700 1630 0 0 {name=lp158 lab=INVO_QP}
C {lab_pin.sym} 3700 1570 0 0 {name=lp159 lab=VDD}
C {lab_pin.sym} 3700 1600 0 0 {name=lp160 lab=VDD}
C {symbols/nfet_03v3.sym} 3680 2000 0 0 {name=M_IN_QP L=0.3u W=4u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 3660 2000 0 0 {name=lp161 lab=OC_QP}
C {lab_pin.sym} 3700 1970 0 0 {name=lp162 lab=INVO_QP}
C {lab_pin.sym} 3700 2030 0 0 {name=lp163 lab=VSS}
C {lab_pin.sym} 3700 2000 0 0 {name=lp164 lab=VSS}
C {res.sym} 3940 1800 0 0 {name=R_SER_QP value=450 footprint=1206 device=resistor m=1}
C {lab_pin.sym} 3940 1770 0 0 {name=lp165 lab=INVO_QP}
C {lab_pin.sym} 3940 1830 0 0 {name=lp166 lab=Q_P}
C {symbols/pfet_03v3.sym} 4400 1600 0 0 {name=M_BT_QN L=0.5u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 4380 1600 0 0 {name=lp167 lab=nPB}
C {lab_pin.sym} 4420 1630 0 0 {name=lp168 lab=BS_QN}
C {lab_pin.sym} 4420 1570 0 0 {name=lp169 lab=VDD}
C {lab_pin.sym} 4420 1600 0 0 {name=lp170 lab=VDD}
C {symbols/pfet_03v3.sym} 4660 1600 0 0 {name=M_BP1_QN L=0.3u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 4640 1600 0 0 {name=lp171 lab=OQ}
C {lab_pin.sym} 4680 1630 0 0 {name=lp172 lab=DN1_QN}
C {lab_pin.sym} 4680 1570 0 0 {name=lp173 lab=BS_QN}
C {lab_pin.sym} 4680 1600 0 0 {name=lp174 lab=VDD}
C {symbols/pfet_03v3.sym} 4920 1600 0 0 {name=M_BP2_QN L=0.3u W=16u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 4900 1600 0 0 {name=lp175 lab=OQB}
C {lab_pin.sym} 4940 1630 0 0 {name=lp176 lab=OC_QN}
C {lab_pin.sym} 4940 1570 0 0 {name=lp177 lab=BS_QN}
C {lab_pin.sym} 4940 1600 0 0 {name=lp178 lab=VDD}
C {symbols/nfet_03v3.sym} 4400 2000 0 0 {name=M_BN1_QN L=0.3u W=8u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 4380 2000 0 0 {name=lp179 lab=DN1_QN}
C {lab_pin.sym} 4420 1970 0 0 {name=lp180 lab=DN1_QN}
C {lab_pin.sym} 4420 2030 0 0 {name=lp181 lab=VSS}
C {lab_pin.sym} 4420 2000 0 0 {name=lp182 lab=VSS}
C {symbols/nfet_03v3.sym} 4660 2000 0 0 {name=M_BN2_QN L=0.3u W=8u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 4640 2000 0 0 {name=lp183 lab=DN1_QN}
C {lab_pin.sym} 4680 1970 0 0 {name=lp184 lab=OC_QN}
C {lab_pin.sym} 4680 2030 0 0 {name=lp185 lab=VSS}
C {lab_pin.sym} 4680 2000 0 0 {name=lp186 lab=VSS}
C {symbols/pfet_03v3.sym} 5180 1600 0 0 {name=M_IP_QN L=0.3u W=8u nf=1 model=pfet_03v3 spiceprefix=X}
C {lab_pin.sym} 5160 1600 0 0 {name=lp187 lab=OC_QN}
C {lab_pin.sym} 5200 1630 0 0 {name=lp188 lab=INVO_QN}
C {lab_pin.sym} 5200 1570 0 0 {name=lp189 lab=VDD}
C {lab_pin.sym} 5200 1600 0 0 {name=lp190 lab=VDD}
C {symbols/nfet_03v3.sym} 5180 2000 0 0 {name=M_IN_QN L=0.3u W=4u nf=1 model=nfet_03v3 spiceprefix=X}
C {lab_pin.sym} 5160 2000 0 0 {name=lp191 lab=OC_QN}
C {lab_pin.sym} 5200 1970 0 0 {name=lp192 lab=INVO_QN}
C {lab_pin.sym} 5200 2030 0 0 {name=lp193 lab=VSS}
C {lab_pin.sym} 5200 2000 0 0 {name=lp194 lab=VSS}
C {res.sym} 5440 1800 0 0 {name=R_SER_QN value=450 footprint=1206 device=resistor m=1}
C {lab_pin.sym} 5440 1770 0 0 {name=lp195 lab=INVO_QN}
C {lab_pin.sym} 5440 1830 0 0 {name=lp196 lab=Q_N}
C {ipin.sym} 2000 -800 0 0 {name=port_CK lab=CK}
C {ipin.sym} 2000 -760 0 0 {name=port_CKB lab=CKB}
C {ipin.sym} 2000 -720 0 0 {name=port_IBIAS lab=IBIAS}
C {iopin.sym} 2000 -680 0 0 {name=port_VDD lab=VDD}
C {iopin.sym} 2000 -640 0 0 {name=port_VSS lab=VSS}
C {opin.sym} 2000 -600 0 0 {name=port_I_P lab=I_P}
C {opin.sym} 2000 -560 0 0 {name=port_I_N lab=I_N}
C {opin.sym} 2000 -520 0 0 {name=port_Q_P lab=Q_P}
C {opin.sym} 2000 -480 0 0 {name=port_Q_N lab=Q_N}
